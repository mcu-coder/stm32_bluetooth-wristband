# Keil uVision project STM32.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Timer;..\HARDWARE\ADC;..\HARDWARE\ADXL345;..\HARDWARE\IIC;..\HARDWARE\OLED;..\HARDWARE\Pedometer;..\HARDWARE\DS18B20;..\HARDWARE\RTC;..\HARDWARE\KEY;..\HARDWARE\stmflash;..\HARDWARE\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Timer/: timer.c
    ../HARDWARE/ADC/: ADC.C
    ../HARDWARE/ADXL345/: adxl345.c
    ../HARDWARE/OLED/: OLED_I2C.c
    ../HARDWARE/Pedometer/: Pedometer.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/stmflash/: stmflash.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_bkp.c stm32f10x_flash.c stm32f10x_exti.c
